# Repository gabriel-bettanin/LAIKA (continued)

## EAGLE design References/Controllers/Moteus driver/r4.4.brd

Parts:
A: PAD; 18AWG_PAD
ABS: JST_ZH4; JST_S4B-ZR-SM4A-TF(LF)(SN); MPN S4B-ZR-SM4A-TF(LF)(SN)
B: PAD; 18AWG_PAD
C: PAD; 18AWG_PAD
C1, C2, C3, C5, C6, C8, C10, C11, C12, C13, C18: 0.1uF; C0402; MPN MF-CAP-0402-0.1uF
C4, C9, C15, C17: 1uF; C0402; MPN MF-CAP-0402-1uF
C7, C21: 10uF; C1206; MPN MF-CAP-1206-10uF
C14, C16, C20: 0.1uF 50V; C0402; MPN CGA2B3X7R1H104K050BB
C19: 0.47uF 50V; C0402; MPN UMK105ABJ474KV-F
C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37: 10uF 50V; C1206; MPN C3216X7R1H106K160AE
CAN1, CAN2: JST-PH3; JST_S3B-PH-SM4-TB(LF)(SN); MPN S3B-PH-SM4-TB(LF)(SN)
D1: MF-DIO-SMA-B140; SMA
D2: MF-LED-0603-RED; LED0603; MPN MF-LED-0603-GREEN
D3: MF-LED-0603-RED; LED0603
D33: PAD24AWG_PAD; 24AWG_PAD
DA: PAD24AWG_PAD; 24AWG_PAD
DAC: PAD24AWG_PAD; 24AWG_PAD
DB: PAD24AWG_PAD; 24AWG_PAD
DBG1, DBG2: PAD24AWG_PAD; 24AWG_PAD
DC: PAD24AWG_PAD; 24AWG_PAD
DG1, DG2: PAD24AWG_PAD; 24AWG_PAD
DRV_CS: PAD24AWG_PAD; 24AWG_PAD
DRV_MISO: PAD24AWG_PAD; 24AWG_PAD
DRV_MOSI: PAD24AWG_PAD; 24AWG_PAD
DRV_SCK: PAD24AWG_PAD; 24AWG_PAD
DTR: PAD24AWG_PAD; 24AWG_PAD
DTX: PAD24AWG_PAD; 24AWG_PAD
J1, J2: XT30XT30PW_MALE; XT30PW_MALE
L1: SRN4018-220M; IND_BOURNS_SRN4018; MPN SRN4018-220M
M1, M2, M3, M4: MOUNT; M2.5MOUNT
MOT1, MOT2, MOT3: PAD24AWG_PAD; 24AWG_PAD
Q1, Q2, Q3, Q4, Q5, Q6: TPH1R204PLSOP_ADVANCE_8; SOP_ADVANCE_8; MPN TPH1R204PL,L1Q
R1, R2: 560; R0402; MPN MF-RES-0402-560
R3, R4, R13, R14: 2k; R0402; MPN MF-RES-0402-2K
R5, R10: 100k 1%; R0402; MPN ERJ-2RKF1003X
R6, R7, R9, R12: 10k 1%; R0402; MPN ERJ-2RKF1002X
R8: 47k NTC; R0402; MPN NCP15WB473F03RC
R11: 33k 1%; R0402; MPN ERJ-2RKF3302X
RA: 0.5mOhm 1% 2W; M1206; MPN HCS1206FTL500
RB: 0.5mOhm 1% 2W; M1206; MPN HCS1206FTL500
RC: 0.5mOhm 1% 2W; M1206; MPN HCS1206FTL500
SH1, SH2, SH3: SHORTT5; SHORT_TOP-50
SH4: SHORTBIG; SHORT_TOP-BIG
SWD: JST-ZH6; JST_S6B-ZR-SM4A-TF(LF)(SN); MPN S6B-ZR-SM4A-TF(LF)(SN)
TEMP1, TEMP2: PAD24AWG_PAD; 24AWG_PAD
U1: STM32G474CEU6; QFN50P700X700X60-49N; MPN STM32G474CEU6
U2: TCAN334GSOT23; SOT23-8; MPN TCAN334GDCNT
U3: AS5147; TSSOP14; MPN AS5047P-ATSM
U4: DRV8323RS; PVQFN-N48; MPN DRV8323RSRGZR

Connections:
+3V3: ABS.1, C1.P$1, C2.P$1, C4.P$1, C5.P$1, C6.P$1, C7.P$2, C8.P$1, C9.P$1, C10.P$1, C11.P$1, C12.P$1, C18.P$2, C21.P$1, D33.P$1, L1.1, R1.P$1, R2.P$1, R3.P$1, R4.P$1, R8.P$1, R11.P$1, R13.P$1, R14.P$1, SWD.6, TEMP1.P$1, U1.1 (VBAT), U1.20 (VREF+), U1.21 (VDDA), U1.23 (VDD_1), U1.35 (VDD_2), U1.48 (VDD_3), U2.3 (VCC), U3.12 (VDD3V), U4.26 (VREF)
AS5047_A: U1.43 (PB5), U3.7 (A)
AS5047_B: U1.42 (PB4), U3.6 (B)
AS5047_CS: U1.24 (PB11), U3.1 (CS/)
AS5047_MISO: U1.27 (PB14), U3.3 (MISO)
AS5047_MOSI: U1.28 (PB15), U3.4 (MOSI)
AS5047_SCK: U1.26 (PB13), U3.2 (CLK)
CAN_N: CAN1.2, CAN2.2, U2.6 (CANL)
CAN_P: CAN1.1, CAN2.1, U2.7 (CANH)
CAN_RX: U1.33 (PA11), U2.4 (RXD)
CAN_TX: U1.34 (PA12), U2.1 (TXD)
CUR1: U1.17 (PB0), U4.25 (SOA)
CUR2: U1.18 (PB1), U4.24 (SOB)
CUR3: U1.19 (PB2), U4.23 (SOC)
DAC: DAC.P$1, U1.12 (PA4)
DEBUG1: DBG1.P$1, U1.3 (PC14-OSC32_IN)
DEBUG2: DBG2.P$1, U1.4 (PC15-OSC32_OUT)
DEBUG_RX: DTR.P$1, U1.40 (PC11)
DEBUG_TX: DTX.P$1, U1.39 (PC10)
DRV8323_CS: DRV_CS.P$1, U1.16 (PC4), U4.32 (CS)
DRV8323_MISO: DRV_MISO.P$1, R13.P$2, U1.14 (PA6), U4.29 (MISO)
DRV8323_MOSI: DRV_MOSI.P$1, U1.15 (PA7), U4.30 (MOSI)
DRV8323_SCLK: DRV_SCK.P$1, U1.13 (PA5), U4.31 (SCLK)
GHA: Q1.4 (G), U4.8 (GHA)
GHB: Q3.4 (G), U4.17 (GHB)
GHC: Q5.4 (G), U4.18 (GHC)
GLA: Q2.4 (G), U4.10 (GLA)
GLB: Q4.4 (G), U4.15 (GLB)
GLC: Q6.4 (G), U4.20 (GLC)
GND: ABS.4, C1.P$2, C2.P$2, C3.P$2, C4.P$2, C5.P$2, C6.P$2, C7.P$1, C8.P$2, C9.P$2, C10.P$2, C11.P$2, C12.P$2, C13.P$2, C17.P$1, C18.P$1, C21.P$2, CAN1.3, CAN2.3, DG1.P$1, DG2.P$1, R6.P$1, R7.P$2, R9.P$2, SH4.2, SWD.4, U1.29 (PC6), U1.49 (THERMALPAD), U2.2 (GND), U2.5 (SHDN), U2.8 (STB), U3.5 (TEST), U3.13 (GND), U4.27 (DGND), U4.35 (AGND)
I2C_ABS_SCL: ABS.2, R4.P$2, U1.46 (PB8-BOOT0)
I2C_ABS_SDA: ABS.3, R3.P$2, U1.47 (PB9)
LED1: D3.CATHODE, U1.5 (PF0-OSC_IN)
LED2: D2.CATHODE, U1.6 (PF1-OSC_OUT)
MOTOR1: MOT1.P$1, U1.8 (PA0), U4.37 (INHA)
MOTOR2: MOT2.P$1, U1.9 (PA1), U4.39 (INHB)
MOTOR3: MOT3.P$1, U1.10 (PA2), U4.41 (INHC)
MOTOR_ENABLE: U1.11 (PA3), U4.33 (ENABLE)
MOTOR_FAULT: R14.P$2, U1.44 (PB6), U4.28 (FAULT)
MOTOR_HIZ: U1.45 (PB7), U4.38 (INLA), U4.40 (INLB), U4.42 (INLC)
unnamed: R10.P$1, U4.48 (SHDN)
unnamed: R11.P$2, R12.P$1, U4.1 (FB)
unnamed: C16.P$2, U4.3 (CPL)
unnamed: C20.P$2, D1.CATHODE, L1.2, U4.45 (SW)
unnamed: C20.P$1, U4.44 (CB)
unnamed: C16.P$1, U4.4 (CPH)
unnamed: C15.P$2, U4.5 (VCP)
unnamed: C17.P$2, U4.36 (DVDD)
unnamed: D3.ANODE, R1.P$2
unnamed: D2.ANODE, R2.P$2
NRST: C3.P$1, SWD.2, U1.7 (PG10-NRST)
SHA: A.1, DA.P$1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.PAD (D), U4.9 (SHA)
SHB: B.1, DB.P$1, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.PAD (D), U4.16 (SHB)
SHC: C.1, DC.P$1, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.PAD (D), U4.19 (SHC)
SNA: SH1.1, U4.12 (SNA)
SNB: SH2.1, U4.13 (SNB)
SNC: SH3.1, U4.22 (SNC)
SPA: Q2.1 (S), Q2.2 (S), Q2.3 (S), RA.2, U4.11 (SPA)
SPB: Q4.1 (S), Q4.2 (S), Q4.3 (S), RB.2, U4.14 (SPB)
SPC: Q6.1 (S), Q6.2 (S), Q6.3 (S), RC.2, U4.21 (SPC)
SWCLK: SWD.5, U1.37 (PA14)
SWDIO: SWD.3, U1.36 (PA13)
V+: C14.P$1, C15.P$1, C19.P$1, C22.P$1, C23.P$1, C24.P$1, C25.P$1, C26.P$1, C27.P$1, C28.P$1, C29.P$1, C30.P$1, C31.P$1, C32.P$1, C33.P$1, C34.P$1, C35.P$1, C36.P$1, C37.P$1, J1.1, J2.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.PAD (D), Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.PAD (D), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.PAD (D), R5.P$2, R10.P$2, U4.6 (VM), U4.7 (VDRAIN), U4.47 (VIN)
V-: C14.P$2, C19.P$2, C22.P$2, C23.P$2, C24.P$2, C25.P$2, C26.P$2, C27.P$2, C28.P$2, C29.P$2, C30.P$2, C31.P$2, C32.P$2, C33.P$2, C34.P$2, C35.P$2, C36.P$2, C37.P$2, D1.ANODE, J1.2, J2.2, R12.P$2, RA.1, RB.1, RC.1, SH1.2, SH2.2, SH3.2, SH4.1, U4.2 (PGND), U4.43 (BGND), U4.P1 (PAD), U4.P2 (PAD), U4.P3 (PAD), U4.P4 (PAD), U4.P5 (PAD), U4.P6 (PAD), U4.P7 (PAD), U4.P8 (PAD), U4.P9 (PAD), U4.P10 (PAD), U4.P11 (PAD), U4.P12 (PAD), U4.P13 (PAD), U4.P14 (PAD), U4.P15 (PAD), U4.P16 (PAD), U4.P17 (PAD), U4.P18 (PAD), U4.P19 (PAD), U4.P20 (PAD), U4.P21 (PAD), U4.P22 (PAD), U4.P23 (PAD), U4.P24 (PAD), U4.P25 (PAD), U4.PAD
VBAT_SENSE: R5.P$1, R6.P$2, U1.25 (PB12)
VTEMP_FET: C13.P$1, R8.P$2, R9.P$1, U1.31 (PA9)
VTEMP_MOT: R7.P$1, TEMP2.P$1, U1.30 (PA8)

Notes on the sheet:
PA10/PC6/PB3 Version 110

Board: 4 copper layers, 46.0 x 53.0 mm, 105 parts (7 on the bottom side), 67 nets.

Notices in the files:
References/Controllers/Moteus driver/r4.4.brd:
(c) 2020
